# Keil uVision project TFT_Demo.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-FLASHLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: stm32f10x_it.c main.c Lcd_Driver.c delay.c GUI.c TFT_demo.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c
  group CMSYS
    ./user/: core_cm3.c system_stm32f10x.c
